# Keil uVision project STM32_PRO.uvprojx, settings and files
target NEW_TEMP (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_PRO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\APP;..\BSP;..\CMSIS;..\FWlib\inc;..\FWlib\src;..\USER;..\Startup;..\HW;..\BSP\STMFLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Startup/: startup_stm32f10x_md.s
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group LIB
    ../FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c
  group BSP
    ../BSP/: usart.c SysTick.c spi.c EXTI.c adc.c
    ../BSP/STMFLASH/: stmflash.c
  group HW
    ../HW/: led.c 24l01.c key.c
  group APP
    ../APP/: ComProtocol.c RCencode.c Timer.c flash.c
  group USER
    ../USER/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group README
    ../: readme.txt
